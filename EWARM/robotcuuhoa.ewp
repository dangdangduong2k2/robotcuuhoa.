# IAR project robotcuuhoa.ewp, settings and files
configuration robotcuuhoa (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: robotcuuhoa.hex
  ILINK.IlinkOutputFile: robotcuuhoa.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c
  group Application/User/Core/0.Peripheral/0.Clock
    ../Core/Src/: clock.c
    ../Core/Inc/: clock.h
  group Application/User/Core/0.Peripheral/1.Gpio
    ../Core/Src/: gpio.c
    ../Core/Inc/: gpio.h
  group Application/User/Core/0.Peripheral/2.Tim
    ../Core/Src/: tim.c tim.h
  group Application/User/Core/0.Peripheral/3.I2c
    ../Core/Src/: i2c.c
    ../Core/Inc/: i2c.h
  group Application/User/Core/0.Peripheral/4.Usart
    ../Core/Inc/: usart.c usart.h
  group Application/User/Core/1.Driver
    ../Core/Src/: dc_send.c fonts.c ssd1306.c
  group Drivers/CMSIS
    ../Core/Src/: stm32f1xx_it.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    ../Core/Src/: stm32f1xx_hal_msp.c
